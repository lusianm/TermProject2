# IAR project TermProject2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: D:\Programming\TermProject2\Libraries\CMSIS\DeviceSupport\Startup; D:\Programming\TermProject2\Libraries\CMSIS\DeviceSupport; D:\Programming\TermProject2\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc; D:\Programming\TermProject2\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src; D:\Programming\TermProject2\user; D:\Programming\TermProject2\user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TermProject2.bin
  ILINK.IlinkOutputFile: TermProject2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    Libraries/STM32F10x_StdPeriph_Driver_v3.5/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
    Libraries/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group user
    user/: FB755AC.c L298N.c lcd.c main.c QMC5883L.c stm32f10x_HC-SR04.c stm32f10x_it.c touch.c
  group user/inc
    user/inc/: FB755AC.h font.h HAL_QMC5883L.h L298N.h lcd.h QMC5883L.h stm32f10x_conf.h stm32f10x_HC-SR04.h stm32f10x_it.h touch.h
